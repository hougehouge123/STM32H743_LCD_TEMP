# Keil uVision project STM32H743_LCD_TEMP.uvprojx, settings and files
target STM32H743_LCD_TEMP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H743_LCD_TEMP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H743xx,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;    ../Drivers/STM32H7xx_HAL_Driver/Inc;    ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;    ../Drivers/CMSIS/Include;    ..\Drivers\TFT_LCD;    ..\Drivers\LVGL;    ..\Drivers\LVGL\demos;    ..\Drivers\LVGL\porting;    ..\Drivers\LVGL\src;    ..\Drivers\SDRAM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fmc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group TFT_LCD
    ../Drivers/TFT_LCD/: font.h ILI93xx.c ILI93xx.h
  group Touch
    ../Drivers/TFT_LCD/: gt9xxx.h gt9xxx.c ctiic.h ctiic.c
  group LVGL
    ../Drivers/LVGL/: lvgl.h lv_conf.h
  group LVGL/Porting
    ../Drivers/LVGL/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group LVGL/Demo
    ../Drivers/LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Drivers/LVGL/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
    ../Drivers/LVGL/demos/keypad_encoder/: lv_demo_keypad_encoder.c lv_demo_keypad_encoder.h
    ../Drivers/LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c spectrum_1.h spectrum_2.h spectrum_3.h
    ../Drivers/LVGL/demos/music/: lv_demo_music.c lv_demo_music.h lv_demo_music_list.c lv_demo_music_list.h lv_demo_music_main.c lv_demo_music_main.h
    ../Drivers/LVGL/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Drivers/LVGL/demos/stress/: lv_demo_stress.c lv_demo_stress.h
    ../Drivers/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../Drivers/LVGL/demos/widgets/: lv_demo_widgets.c lv_demo_widgets.h
    ../Drivers/LVGL/demos/: lv_demos.h
  group LVGL/Src
    ../Drivers/LVGL/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ../Drivers/LVGL/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
    ../Drivers/LVGL/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
    ../Drivers/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
    ../Drivers/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
    ../Drivers/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Drivers/LVGL/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
    ../Drivers/LVGL/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ../Drivers/LVGL/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ../Drivers/LVGL/src/extra/layouts/: lv_layouts.h
    ../Drivers/LVGL/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
    ../Drivers/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
    ../Drivers/LVGL/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
    ../Drivers/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ../Drivers/LVGL/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
    ../Drivers/LVGL/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
    ../Drivers/LVGL/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
    ../Drivers/LVGL/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
    ../Drivers/LVGL/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
    ../Drivers/LVGL/src/extra/libs/: lv_libs.h
    ../Drivers/LVGL/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ../Drivers/LVGL/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
    ../Drivers/LVGL/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../Drivers/LVGL/src/extra/others/: lv_others.h
    ../Drivers/LVGL/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ../Drivers/LVGL/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ../Drivers/LVGL/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../Drivers/LVGL/src/extra/themes/: lv_themes.h
    ../Drivers/LVGL/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ../Drivers/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ../Drivers/LVGL/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ../Drivers/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ../Drivers/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ../Drivers/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ../Drivers/LVGL/src/extra/widgets/led/: lv_led.c lv_led.h
    ../Drivers/LVGL/src/extra/widgets/list/: lv_list.c lv_list.h
    ../Drivers/LVGL/src/extra/widgets/menu/: lv_menu.c lv_menu.h
    ../Drivers/LVGL/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ../Drivers/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ../Drivers/LVGL/src/extra/widgets/span/: lv_span.c lv_span.h
    ../Drivers/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ../Drivers/LVGL/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../Drivers/LVGL/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ../Drivers/LVGL/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ../Drivers/LVGL/src/extra/widgets/win/: lv_win.c lv_win.h
    ../Drivers/LVGL/src/extra/widgets/: lv_widgets.h
    ../Drivers/LVGL/src/extra/: lv_extra.c lv_extra.h
    ../Drivers/LVGL/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../Drivers/LVGL/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
    ../Drivers/LVGL/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
    ../Drivers/LVGL/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
    ../Drivers/LVGL/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group SDRAM
    ../Drivers/SDRAM/: sdram.c sdram.h
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
